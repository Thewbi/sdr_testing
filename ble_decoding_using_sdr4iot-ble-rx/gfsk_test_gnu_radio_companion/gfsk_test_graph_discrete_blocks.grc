options:
  parameters:
    author: Jan Wagner
    generate_options: no_gui
    id: gr_ble
    output_language: python
    title: Bluetooth LE Receiver
  states: {}

blocks:
- name: ble_base_freq
  id: variable
  parameters:
    value: 2402e6
  states: {}
- name: ble_channel
  id: variable
  parameters:
    value: '12'
  states: {}
- name: ble_channel_spacing
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: cutoff_freq
  id: variable
  parameters:
    value: 850e3
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: duration_seconds
  id: variable
  parameters:
    value: '30'
  states: {}
- name: freq
  id: variable
  parameters:
    value: ble_base_freq+(ble_channel_spacing * ble_channel)
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: gmsk_gain_mu
  id: variable
  parameters:
    value: '0.7'
  states: {}
- name: gmsk_mu
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: gmsk_omega_limit
  id: variable
  parameters:
    value: '0.035'
  states: {}
- name: gmsk_sps
  id: variable
  parameters:
    value: int(sample_rate/data_rate)
  states: {}
- name: iq_output
  id: variable
  parameters:
    comment: Filename for I/Q output.
    value: '"/dev/null"'
  states: {}
- name: lowpass_filter
  id: variable
  parameters:
    value: firdes.low_pass(1, sample_rate, cutoff_freq, transition_width)
  states: {}
- name: num_samples
  id: variable
  parameters:
    value: duration_seconds*sample_rate
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: squelch_threshold
  id: variable
  parameters:
    value: '-70'
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 1.0/((numpy.pi*0.5)/gmsk_sps)
  states: {}
- name: analog_simple_squelch
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.1'
    threshold: squelch_threshold
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: iq_output
    type: complex
  states: {}
- name: blocks_file_sink_4_0
  id: blocks_file_sink
  parameters:
    file: tmp/gfsk_demod_custom.dat
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_4_0_0
  id: blocks_file_sink
  parameters:
    file: tmp/quadrature_demod_output.dat
    type: float
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_4_0_0_0
  id: blocks_file_sink
  parameters:
    file: tmp/symbol_sink_output.dat
    type: float
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_4_0_1
  id: blocks_file_sink
  parameters:
    file: tmp/gfsk_demod_custom_gfsk_block.dat
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_4_0_1_0
  id: blocks_file_sink
  parameters:
    file: tmp/gfsk_demod_custom_gfsk_block_packed.dat
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(num_samples)
    type: complex
  states: {}
- name: blocks_uchar_to_float_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: gmsk_sps
    sensitivity: (numpy.pi*0.5)/gmsk_sps
    verbose: 'True'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.096'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '10'
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: freq_xlating_fir_filter_lp
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-freq_offset'
    decim: '1'
    samp_rate: sample_rate
    taps: lowpass_filter
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    marker1: '1'
    size: '100'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '0'
    freq0: freq+freq_offset
    gain0: '100'
    gain_mode0: 'False'
    if_gain0: '89'
    sample_rate: sample_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: unpacked_to_packed
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {state: disabled}
- name: unpacked_to_packed_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:55555
    timeout: '100'
    type: byte
  states: {state: disabled}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:55555
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_file_sink_4_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_simple_squelch, '0', freq_xlating_fir_filter_lp, '0']
- [blocks_head_0, '0', analog_simple_squelch, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_1_0, '0']
- [digital_binary_slicer_fb_0, '0', unpacked_to_packed_0, '0']
- [digital_gfsk_demod_0, '0', blocks_file_sink_4_0_1, '0']
- [digital_gfsk_demod_0, '0', unpacked_to_packed, '0']
- [digital_symbol_sync_xx_0, '0', blocks_file_sink_4_0_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [freq_xlating_fir_filter_lp, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_lp, '0', digital_gfsk_demod_0, '0']
- [rtlsdr_source_0, '0', blocks_head_0, '0']
- [unpacked_to_packed, '0', blocks_file_sink_4_0_1_0, '0']
- [unpacked_to_packed, '0', zeromq_pub_sink_0, '0']
- [unpacked_to_packed_0, '0', blocks_file_sink_4_0, '0']
- [unpacked_to_packed_0, '0', zeromq_pub_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
